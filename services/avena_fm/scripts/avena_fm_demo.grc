options:
  parameters:
    generate_options: no_gui
    id: avena_fm_demo
    output_language: python
    run_options: run
    title: RTL-SDR FM Tuner
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44000'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '100000.0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 98.7e06
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: ft
  id: variable
  parameters:
    value: 98.7e06
  states: {}
- name: max_buff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: min_buff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e06
  states: {}
- name: sdr_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: stream
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate/200000)
    maxoutbuf: max_buff
    minoutbuf: min_buff
    quad_rate: quadrature
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '256'
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '256'
    max_iter: '1'
    scale: 1.0/256.0
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: fc
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: sdr_gain
  states: {}
- name: blocks_msgpair_to_var_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: ft
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: stream
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'False'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import numpy as np
      from gnuradio import gr
      from pynats2 import NATSClient
      import json
      from base64 import b64encode, b64decode

      class NumpyEncoder(json.JSONEncoder):
          def default(self, obj):
              if isinstance(obj, np.ndarray):
                  return obj.tolist()
              return json.JSONEncoder.default(self, obj)

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block


          def __init__(self, vector_size=1024, subject='fft', 
                       nats_server='nats://localhost:4222',
                       freq=98700000, span=2000000, stream=False, gain=0):  # only default arguments here

              gr.sync_block.__init__(
                  self,
                  name='NATS Sink',   # will show up in GRC
                  in_sig=[(np.ushort, vector_size)],
                  out_sig=None
              )

              avena_prefix = os.getenv('AVENA_PREFIX')
              self.vector_size = vector_size
              self.freq = freq
              self.span = span
              self.stream = stream
              self.gain = gain
              self.subject = subject
              #self.subject = avena_prefix + '.' + subject
              self.nc = NATSClient(nats_server, socket_timeout=2)
              self.nc.connect()
              
          def work(self, input_items, output_items):
              
              b64encpayload = str(b64encode(input_items[0][0]), 'utf-8')
              json_dump = json.dumps({'fft': b64encpayload,
                                      'fc' : self.freq,
                                      'gain' : self.gain, 
                                      'span' : self.span, 
                                      'fft_size' : self.vector_size,
                                      'stream' : self.stream}, 
                                      cls=NumpyEncoder)
              self.nc.publish(subject=self.subject ,payload=json_dump)
              
              return len(input_items[0])
    freq: fc
    gain: sdr_gain
    maxoutbuf: max_buff
    minoutbuf: min_buff
    nats_server: '''nats://localhost:4222'''
    span: samp_rate
    stream: stream
    subject: '''sdr.fft'''
    vector_size: fft_size
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\nimport os\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nfrom pynats2 import NATSClient\nimport json\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self, nats_server='nats://localhost:4222', \n                 subject='sdr.control'):  # only default arguments here\n        gr.sync_block.__init__(\n            self,\n            name='NATS Subscription',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        avena_prefix = os.getenv('AVENA_PREFIX')\n        self.port_1 = 'Frequency'\n        self.port_2 = 'Center Frequency'\n        self.port_3 = 'Gain'\n        self.port_4 = 'Stream Control'\n        self.port_5 = 'Stream Status' # THERE MIGHT BE BETTER WAYS TO DO THIS!\n        #self.subject = avena_prefix + '.' + subject\n        self.subject = subject\n        self.message_port_register_out(pmt.intern(self.port_1))\n        self.message_port_register_out(pmt.intern(self.port_2))\n        self.message_port_register_out(pmt.intern(self.port_3))   \n        self.message_port_register_out(pmt.intern(self.port_4))\n        self.message_port_register_out(pmt.intern(self.port_5))             \n        self.nc = NATSClient(nats_server, socket_timeout=2)\n        self.nc.connect()\n        self.nc.subscribe(subject=self.subject, callback=self.callback)\n        \n    \n    def callback(self, msg):\n\t\n        nats_msg = json.loads(msg.payload.decode())    \n        PMT_msg_1 = pmt.cons(pmt.string_to_symbol('ft'), \n                  pmt.from_long(nats_msg['ft']))\n        PMT_msg_2 = pmt.cons(pmt.string_to_symbol('fc'), \n                  pmt.from_long(nats_msg['fc']))\n        PMT_msg_3 = pmt.cons(pmt.string_to_symbol('gain'), \n                  pmt.from_long(nats_msg['gain']))\n        PMT_msg_4 = pmt.to_pmt(nats_msg['stream'])\n        PMT_msg_5 = pmt.cons(pmt.string_to_symbol('stream'), \n                  pmt.from_bool(nats_msg['stream']))\n        \n        self.message_port_pub(pmt.intern(self.port_1), PMT_msg_1)\n        self.message_port_pub(pmt.intern(self.port_2), PMT_msg_2)\n        self.message_port_pub(pmt.intern(self.port_3), PMT_msg_3)\n        self.message_port_pub(pmt.intern(self.port_4), PMT_msg_4)\n        self.message_port_pub(pmt.intern(self.port_5), PMT_msg_5)\n        \n        print(f\"Frequency set to {nats_msg['ft']} Hz\")\n        print(f\"Center Frequency set to {nats_msg['fc']} Hz\")\n        print(f\"Gain set to {nats_msg['gain']} dB\")\n        print(f\"Streaming: {nats_msg['stream']}\")   \n             \n    def work(self, input_items, output_items):\n        \n        return len(input_items[0])\n        \n        \n"
    nats_server: '''nats://localhost:4222'''
    subject: '''sdr.control'''
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, scale=1, vector_size=1024):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Float to UShort',   # will show up in GRC
                  in_sig=[(np.single, vector_size)],
                  out_sig=[(np.ushort, vector_size)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.scale = scale

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.ushort(input_items[0] * self.scale)
              return len(output_items[0])
    scale: '10000'
    vector_size: fft_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft-fc
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), transition_bw)'
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/40000)
    interp: int(audio_rate/10000*samp_rate/200000)
    maxoutbuf: max_buff
    minoutbuf: min_buff
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: ft
    gain0: sdr_gain
    gain_mode0: 'False'
    if_gain0: '20'
    maxoutbuf: max_buff
    minoutbuf: min_buff
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_3, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_null_source_0, '0', epy_block_1, '0']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_1, Center Frequency, blocks_msgpair_to_var_0, inpair]
- [epy_block_1, Frequency, blocks_msgpair_to_var_0_1, inpair]
- [epy_block_1, Gain, blocks_msgpair_to_var_0_0, inpair]
- [epy_block_1, Stream Control, blocks_selector_0, en]
- [epy_block_1, Stream Status, blocks_msgpair_to_var_1, inpair]
- [epy_block_3, '0', epy_block_0, '0']
- [fft_vxx_0, '0', blocks_moving_average_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', network_udp_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
